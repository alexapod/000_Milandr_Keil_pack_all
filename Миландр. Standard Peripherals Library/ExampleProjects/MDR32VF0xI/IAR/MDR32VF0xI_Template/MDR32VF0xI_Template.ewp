# IAR project MDR32VF0xI_Template.ewp, settings and files
configuration MDR1206FI FLASH (RISCV, debug)
  General.GDeviceSelect: MDR1206FI Milandr MDR1206FI
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCIncludePath2: Library\CMSIS\CoreSupport\inc; Library\CMSIS\DeviceSupport; Library\CMSIS\DeviceSupport\inc; Library\SPL; Library\SPL\inc; src
  IASMRISCV.AsmIncludePath: Library\CMSIS\CoreSupport\inc; Library\CMSIS\DeviceSupport\inc; Library\CMSIS\DeviceSupport; Library\SPL\inc; Library\SPL
  OBJCOPY.OOCOutputFile: MDR32VF0xI_Template.hex
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MDR1206FI RAM_TCM_Debug (RISCV, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: MDR1206_Template.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Milandr\MDR32VF0xI\MDR1206\MDR1206_RAM_TCM.icf
configuration MDR1206AFI FLASH (RISCV, debug)
  as the first configuration, except:
  General.GDeviceSelect: MDR1206AFI Milandr MDR1206AFI
  OBJCOPY.OOCOutputFile: MDR1206_Template.hex
configuration MDR1206AFI RAM_TCM_Debug (RISCV, debug)
  as the first configuration, except:
  General.GDeviceSelect: MDR1206AFI Milandr MDR1206AFI
  OBJCOPY.OOCOutputFile: MDR1206_Template.hex
  ILINK.IlinkIcfFile: as above
configuration MDR32F02 FLASH (RISCV, debug)
  as the first configuration, except:
  General.GDeviceSelect: MDR32F02 Milandr MDR32F02
configuration MDR32F02 RAM_TCM_Debug (RISCV, debug)
  as the first configuration, except:
  General.GDeviceSelect: MDR32F02 Milandr MDR32F02
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Milandr\MDR32VF0xI\MDR32F02\MDR32F02_RAM_TCM.icf
  group Library/CMSIS/CoreSupport/inc
    Library/CMSIS/CoreSupport/inc/: core_bm310s.h core_clic.h core_clint.h core_compiler.h core_csr.h core_extension_m.h core_extension_xgost.h core_extension_zicntr.h core_extension_zifencei.h core_plic.h core_pmp.h core_types.h
  group Library/CMSIS/CoreSupport/src
    Library/CMSIS/CoreSupport/src/: core_clic.c core_clint.c core_plic.c core_pmp.c
  group Library/CMSIS/DeviceSupport
    Library/CMSIS/DeviceSupport/: system_MDR32VF0xI_config.h
  group Library/CMSIS/DeviceSupport/inc
    Library/CMSIS/DeviceSupport/inc/: core_config.h MDR32VF0xI.h system_MDR32VF0xI.h system_MDR32VF0xI_it.h system_MDR32VF0xI_sections.h
  group Library/CMSIS/DeviceSupport/src
    Library/CMSIS/DeviceSupport/src/iar/MDR32F02/: startup_MDR32F02.s
    Library/CMSIS/DeviceSupport/src/iar/MDR1206/: startup_MDR1206.s
    Library/CMSIS/DeviceSupport/src/: system_MDR32VF0xI.c system_MDR32VF0xI_it.c
  group Library/SPL
    Library/SPL/: MDR32VF0xI_config.h
  group Library/SPL/inc
    Library/SPL/inc/: MDR32VF0xI_adc.h MDR32VF0xI_adcui.h MDR32VF0xI_bkp.h MDR32VF0xI_clk_measure.h MDR32VF0xI_crc.h MDR32VF0xI_dma.h MDR32VF0xI_flash.h MDR32VF0xI_i2c.h MDR32VF0xI_iwdg.h MDR32VF0xI_l_block.h MDR32VF0xI_otp.h MDR32VF0xI_p_bit.h MDR32VF0xI_p_byte.h MDR32VF0xI_port.h MDR32VF0xI_power.h MDR32VF0xI_random.h MDR32VF0xI_rst_clk.h MDR32VF0xI_s_block.h MDR32VF0xI_sensors.h MDR32VF0xI_ssp.h MDR32VF0xI_timer.h MDR32VF0xI_uart.h MDR32VF0xI_usart.h MDR32VF0xI_utils.h MDR32VF0xI_wwdg.h
  group Library/SPL/src
    Library/SPL/src/: MDR32VF0xI_adc.c MDR32VF0xI_adcui.c MDR32VF0xI_asm.S MDR32VF0xI_bkp.c MDR32VF0xI_clk_measure.c MDR32VF0xI_crc.c MDR32VF0xI_dma.c MDR32VF0xI_flash.c MDR32VF0xI_i2c.c MDR32VF0xI_iwdg.c MDR32VF0xI_l_block.c MDR32VF0xI_otp.c MDR32VF0xI_port.c MDR32VF0xI_power.c MDR32VF0xI_random.c MDR32VF0xI_rst_clk.c MDR32VF0xI_sensors.c MDR32VF0xI_ssp.c MDR32VF0xI_timer.c MDR32VF0xI_uart.c MDR32VF0xI_usart.c MDR32VF0xI_utils.c MDR32VF0xI_wwdg.c
  group Src
    src/: main.c
