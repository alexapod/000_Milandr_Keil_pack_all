<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MDR32FG16S1QI\HelloWorld_MDR32FG16S1QI\HelloWorld_MDR32FG16S1QI.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MDR32F1QI\HelloWorld_MDR32F1QI\HelloWorld_MDR32F1QI.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MDR32F9Q2I\HelloWorld_MDR32F9Q2I\HelloWorld_MDR32F9Q2I.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\K1986VE92xI\HelloWorld_K1986VE92xI\HelloWorld_K1986VE92xI.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MDR1986VK01\HelloWorld_MDR1986VK01\HelloWorld_MDR1986VK01.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MDR1986VK01\HelloWorld_DualCore_MDR1986VK01\HelloWorld_DualCore_MDR1986VK01.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>BuildAll</name>
            <member>
                <project>HelloWorld_MDR32FG16S1QI</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>HelloWorld_MDR32FG16S1QI</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>HelloWorld_MDR32F1QI</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>HelloWorld_MDR32F1QI</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>HelloWorld_MDR32F9Q2I</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>HelloWorld_MDR32F9Q2I</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>HelloWorld_K1986VE92xI</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>HelloWorld_K1986VE92xI</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>HelloWorld_MDR1986VK01</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>HelloWorld_MDR1986VK01</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>HelloWorld_DualCore_MDR1986VK01</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>HelloWorld_DualCore_MDR1986VK01</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
