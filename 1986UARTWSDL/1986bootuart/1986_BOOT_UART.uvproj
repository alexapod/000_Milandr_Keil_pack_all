# Keil uVision project 1986_BOOT_UART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: 1986_BOOT_UART +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x20007800 size 0x400
  memory RVCT9: RAM 0x20007c00 size 0x400
  group Source Group 1
    ./: startup_1986bootuart.s bootuart.c
